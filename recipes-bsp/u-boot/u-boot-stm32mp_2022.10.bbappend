FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-adding-stm32mp135d-odyssey-dts-files.patch file://0002-modified-stm32mp13_defconfig.patch file://0003-modified-defconfig.patch file://0004-added-seeed-studio-files.patch"

