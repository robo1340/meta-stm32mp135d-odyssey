FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-added-stm32mp135d-odyssey-dts-files.patch file://0002-changing-CFG_TZDRAM_SIZE.patch file://0003-added-seeed-studio-files.patch file://0004-edit-to-stm32mp135d-odyssey.patch"

